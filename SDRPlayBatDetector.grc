options:
  parameters:
    author: JoeTester1965
    copyright: MIT License
    generate_options: no_gui
    id: SDRPlayBatDetector
    output_language: python
    run_options: run
    title: SDRPlayBatDetector-grc
  states: {}

blocks:
- name: audio_bat_port
  id: variable_config
  parameters:
    config_file: ./SDRPlayBatDetector.ini
    option: audio_bat_port
    section: client
    type: int
    value: '50243'
    writeback: None
  states: {}
- name: audio_conversion_gain
  id: variable_config
  parameters:
    config_file: ./SDRPlayBatDetector.ini
    option: audio_conversion_gain
    section: graph
    type: int
    value: '2'
    writeback: None
  states: {}
- name: audio_ip_address
  id: variable_config
  parameters:
    config_file: ./SDRPlayBatDetector.ini
    option: audio_ip_address
    section: client
    type: string
    value: 127.0.0.1
    writeback: None
  states: {}
- name: audio_speech_port
  id: variable_config
  parameters:
    config_file: ./SDRPlayBatDetector.ini
    option: audio_speech_port
    section: client
    type: int
    value: '50244'
    writeback: None
  states: {}
- name: bat_tuning_frequency
  id: variable_config
  parameters:
    config_file: ./SDRPlayBatDetector.ini
    option: bat_tuning_frequency
    section: graph
    type: int
    value: '60000'
    writeback: None
  states: {}
- name: decimation
  id: variable_config
  parameters:
    config_file: ./SDRPlayBatDetector.ini
    option: decimation
    section: graph
    type: int
    value: '10'
    writeback: None
  states: {}
- name: fft_frame_rate
  id: variable_config
  parameters:
    config_file: ./SDRPlayBatDetector.ini
    option: fft_frame_rate
    section: graph
    type: int
    value: '10'
    writeback: None
  states: {}
- name: fft_resolution
  id: variable_config
  parameters:
    config_file: ./SDRPlayBatDetector.ini
    option: fft_resolution
    section: graph
    type: int
    value: '1024'
    writeback: None
  states: {}
- name: samp_rate
  id: variable_config
  parameters:
    config_file: ./SDRPlayBatDetector.ini
    option: samp_rate
    section: graph
    type: int
    value: '250000'
    writeback: None
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_correctiq_0
  id: blocks_correctiq
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: bat-recording
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    begin_tag: pmt.intern("bat")
    file: bat-recording
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_conversion_gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_conversion_gain
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: bat_tuning_frequency
    decim: decimation
    samp_rate: samp_rate
    taps: ' firdes.low_pass(1,samp_rate,samp_rate/decimation/3,100)'
    type: ccc
  states: {}
- name: logpwrfft_x_0
  id: logpwrfft_x
  parameters:
    alias: audio
    average: 'True'
    avg_alpha: '1.0'
    fft_size: fft_resolution
    frame_rate: fft_frame_rate
    ref_scale: '1'
    sample_rate: samp_rate
    shift: 'True'
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '7000'
    decim: '10'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: audio_ip_address
    header: '0'
    payloadsize: '1472'
    port: '50243'
    send_eof: 'False'
    type: float
  states: {}
- name: network_udp_sink_0_0
  id: network_udp_sink
  parameters:
    addr: audio_ip_address
    header: '0'
    payloadsize: '1472'
    port: audio_speech_port
    send_eof: 'False'
    type: float
  states: {}
- name: note_0
  id: note
  parameters:
    note: zmqpubsink.py
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: zmqpubsink.py
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/10
    color1: '1'
    fc: tuning_frequency
    fftsize: fft_resolution
    int_max: '-30'
    int_min: '-100'
    name: Selected xlated audio
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    color1: '1'
    fc: '0'
    fftsize: '1024'
    int_max: '-30'
    int_min: '-100'
    name: Broadband audio
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '25'
    interp: '16'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '25'
    interp: '16'
    type: ccc
  states: {}
- name: sdrplay3_rspdxr2_0
  id: sdrplay3_rspdxr2
  parameters:
    AGC: 'False'
    agc_set_point: '0'
    antenna: Antenna B
    bandwidth: '0'
    biasT: 'False'
    center_freq: '0'
    dab_notch_filter: 'False'
    dc_offset_mode: 'True'
    debug_mode: 'False'
    freq_corr: '0'
    hdr_mode: 'False'
    if_gRdB: '36'
    iq_balance_mode: 'True'
    output_type: fc32
    rf_gRLNA: '0'
    rf_gR_mode: LNA
    rf_gRdB: '27'
    rf_notch_filter: 'False'
    rsp_selector: ''
    sample_rate: samp_rate
    sample_sequence_gaps_check: 'False'
    show_gain_changes: 'False'
    showports: 'False'
    stream_tags: 'False'
    synchronous_updates: 'False'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: audio_processing
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: audio_processing
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:50242
    timeout: '100'
    type: float
    vlen: fft_resolution
  states: {}
- name: zeromq_pull_msg_source_0
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://127.0.0.1:50241
    timeout: '100'
  states: {}

connections:
- [blocks_complex_to_real_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_real_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_correctiq_0, '0', blocks_file_sink_0, '0']
- [blocks_correctiq_0, '0', logpwrfft_x_0, '0']
- [blocks_correctiq_0, '0', qtgui_waterfall_sink_x_1, '0']
- [blocks_correctiq_0, '0', virtual_sink_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_const_vxx_0, '0', network_udp_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', network_udp_sink_0_0, '0']
- [blocks_throttle_0, '0', logpwrfft_x_0, '0']
- [blocks_throttle_0, '0', virtual_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', rational_resampler_xxx_0_0, '0']
- [logpwrfft_x_0, '0', zeromq_pub_sink_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_complex_to_real_0_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_complex_to_real_0, '0']
- [sdrplay3_rspdxr2_0, '0', blocks_correctiq_0, '0']
- [virtual_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [virtual_source_0, '0', low_pass_filter_0, '0']
- [zeromq_pull_msg_source_0, out, freq_xlating_fir_filter_xxx_0, freq]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
