options:
  parameters:
    author: JoeTester1965
    copyright: MIT License
    generate_options: no_gui
    id: SDRPlayBatDetector
    output_language: python
    run_options: run
    title: SDRPlayBatDetector-grc
  states: {}

blocks:
- name: decimation
  id: variable
  parameters:
    value: '10'
  states: {}
- name: default_tuning_frequency
  id: variable_config
  parameters:
    config_file: ./SDRPlayBatDetector.ini
    option: default_tuning_frequency
    section: graph
    type: int
    value: '50000'
    writeback: None
  states: {}
- name: fft_frame_rate
  id: variable_config
  parameters:
    config_file: ./SDRPlayBatDetector.ini
    option: fft_frame_rate
    section: graph
    type: int
    value: '10'
    writeback: None
  states: {}
- name: fft_resolution
  id: variable_config
  parameters:
    config_file: ./SDRPlayBatDetector.ini
    option: fft_resolution
    section: graph
    type: int
    value: '512'
    writeback: None
  states: {}
- name: samp_rate
  id: variable_config
  parameters:
    config_file: ./SDRPlayBatDetector.ini
    option: samp_rate
    section: graph
    type: int
    value: '250000'
    writeback: None
  states: {}
- name: squelch
  id: variable_config
  parameters:
    config_file: ./SDRPlayBatDetector.ini
    option: squelch
    section: graph
    type: int
    value: '-50'
    writeback: None
  states: {}
- name: analog_feedforward_agc_cc_0
  id: analog_feedforward_agc_cc
  parameters:
    num_samples: '1024'
    reference: '0.5'
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '1000'
    threshold: squelch
    type: complex
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '24000'
  states: {state: disabled}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_correctiq_0
  id: blocks_correctiq
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: bat-recording
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    begin_tag: pmt.intern("bat")
    file: bat-recording
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: default_tuning_frequency
    decim: decimation
    samp_rate: samp_rate
    taps: ' firdes.low_pass(1,samp_rate,samp_rate/decimation/2,1000)'
    type: ccc
  states: {}
- name: logpwrfft_x_0
  id: logpwrfft_x
  parameters:
    average: 'True'
    avg_alpha: '1.0'
    fft_size: fft_resolution
    frame_rate: fft_frame_rate
    ref_scale: '1'
    sample_rate: samp_rate
    shift: 'True'
    type: complex
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 192.168.1.77
    header: '0'
    payloadsize: '1472'
    port: '50243'
    send_eof: 'False'
    type: float
  states: {}
- name: note_0
  id: note
  parameters:
    note: zmqpubsink.py
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: zmqpubsink.py
  states: {}
- name: note_0_1
  id: note
  parameters:
    note: ffplay -f f32le -ar 24000 -sync ext -fflags nobuffer -nodisp -i udp://127.0.0.1:50243
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    average: '0.1'
    ref_level: '-80'
    vlen: fft_resolution
    x_start: '0'
    x_step: '1.0'
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    color1: '1'
    fc: '0'
    fftsize: fft_resolution
    int_max: '-30'
    int_min: '-100'
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '25'
    interp: '24'
    type: ccc
  states: {}
- name: sdrplay3_rspdxr2_0
  id: sdrplay3_rspdxr2
  parameters:
    AGC: 'False'
    agc_set_point: '-30'
    antenna: Antenna C
    bandwidth: '0'
    biasT: 'False'
    center_freq: '0'
    dab_notch_filter: 'False'
    dc_offset_mode: 'False'
    debug_mode: 'False'
    freq_corr: '0'
    hdr_mode: 'False'
    if_gRdB: '53'
    iq_balance_mode: 'False'
    output_type: fc32
    rf_gRLNA: '0'
    rf_gR_mode: dB
    rf_gRdB: '0'
    rf_notch_filter: 'False'
    rsp_selector: ''
    sample_rate: samp_rate
    sample_sequence_gaps_check: 'False'
    show_gain_changes: 'False'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: audio_processing
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: audio_processing
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:50242
    timeout: '100'
    type: float
    vlen: fft_resolution
  states: {}
- name: zeromq_pull_msg_source_0
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://127.0.0.1:50241
    timeout: '100'
  states: {}

connections:
- [analog_feedforward_agc_cc_0, '0', rational_resampler_xxx_0, '0']
- [analog_pwr_squelch_xx_0, '0', analog_feedforward_agc_cc_0, '0']
- [blocks_complex_to_real_0, '0', audio_sink_0, '0']
- [blocks_complex_to_real_0, '0', network_udp_sink_0, '0']
- [blocks_correctiq_0, '0', blocks_file_sink_0, '0']
- [blocks_correctiq_0, '0', logpwrfft_x_0, '0']
- [blocks_correctiq_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_correctiq_0, '0', virtual_sink_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', logpwrfft_x_0, '0']
- [blocks_throttle_0, '0', virtual_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_pwr_squelch_xx_0, '0']
- [logpwrfft_x_0, '0', qtgui_vector_sink_f_0, '0']
- [logpwrfft_x_0, '0', zeromq_pub_sink_0, '0']
- [rational_resampler_xxx_0, '0', blocks_complex_to_real_0, '0']
- [sdrplay3_rspdxr2_0, '0', blocks_correctiq_0, '0']
- [virtual_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [zeromq_pull_msg_source_0, out, freq_xlating_fir_filter_xxx_0, freq]

metadata:
  file_format: 1
  grc_version: 3.10.5.1
